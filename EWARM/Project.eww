<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F401_Cube_FW_F4_V1.23.0_UART_RX_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
